# IAR project tran_receTest_core0.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM6750xVMx HPMicro HPM6750xVMx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; INIT_EXT_RAM_FOR_DATA=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_ADC12=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_CAN=y; HPMSOC_HAS_HPMSDK_WDG=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMA=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDM=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_HALL=y; HPMSOC_HAS_HPMSDK_QEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_LCDC=y; HPMSOC_HAS_HPMSDK_CAM=y; HPMSOC_HAS_HPMSDK_PDMA=y; HPMSOC_HAS_HPMSDK_JPEG=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDXC=y; HPMSOC_HAS_HPMSDK_CONCTL=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_VAD=y; HPMSOC_HAS_HPMSDK_PLLCTL=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BUTN=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y
  ICCRISCV.CCIncludePath2: ../../../../../../arch; ../../../../../../arch/riscv/l1c; ../../../../../../boards/hpm6750evkmini; ../../../../../../soc/HPM6700/HPM6750; ../../../../../../soc/HPM6700/ip; ../../../../../../soc/HPM6700/HPM6750/toolchains; ../../../../../../soc/HPM6700/HPM6750/boot; ../../../../../../drivers/inc; ../../../../../../utils; ../../../../../../components/debug_console; ../build_tmp/generated/include; ../../../../common; ../../../inc; ../../../../../../../../../soc/HPM6700/ip
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=8M; _extram_size=16M
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\soc\HPM6700\HPM6750\toolchains\iar\flash_sdram_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; INIT_EXT_RAM_FOR_DATA=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_ADC12=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_CAN=y; HPMSOC_HAS_HPMSDK_WDG=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMA=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDM=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_HALL=y; HPMSOC_HAS_HPMSDK_QEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_LCDC=y; HPMSOC_HAS_HPMSDK_CAM=y; HPMSOC_HAS_HPMSDK_PDMA=y; HPMSOC_HAS_HPMSDK_JPEG=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDXC=y; HPMSOC_HAS_HPMSDK_CONCTL=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_VAD=y; HPMSOC_HAS_HPMSDK_PLLCTL=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BUTN=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; NDEBUG
  group sdk_sample/mytest/tran_receTest/src
    ../../../src/: tran_receTest.c sec_core_img.c app_mbx.c can_test.c share_buffer.c
  group sdk_sample/mytest/common
    ../../../../common/: multicore_common.c
  group soc/HPM6700/HPM6750
    ../../../../../../soc/HPM6700/HPM6750/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c
  group soc/HPM6700/HPM6750/toolchains
    ../../../../../../soc/HPM6700/HPM6750/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM6700/HPM6750/toolchains/iar
    ../../../../../../soc/HPM6700/HPM6750/toolchains/iar/: startup.s
  group soc/HPM6700/HPM6750/boot
    ../../../../../../soc/HPM6700/HPM6750/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../../arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm6750evkmini
    ../../../../../../boards/hpm6750evkmini/: pinmux.c board.c
  group drivers/src
    ../../../../../../drivers/src/: hpm_uart_drv.c hpm_femc_drv.c hpm_sdp_drv.c hpm_lcdc_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_pdma_drv.c hpm_wdg_drv.c hpm_dma_drv.c hpm_gptmr_drv.c hpm_pwm_drv.c hpm_pllctl_drv.c hpm_usb_drv.c hpm_rtc_drv.c hpm_acmp_drv.c hpm_i2s_drv.c hpm_dao_drv.c hpm_pdm_drv.c hpm_vad_drv.c hpm_cam_drv.c hpm_can_drv.c hpm_jpeg_drv.c hpm_enet_drv.c hpm_sdxc_drv.c hpm_adc12_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_qei_drv.c hpm_tamp_drv.c
  group utils
    ../../../../../../utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../../components/debug_console/: hpm_debug_console.c
